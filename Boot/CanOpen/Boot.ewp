# IAR project Boot.ewp, settings and files
configuration Build (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C6 ST STM32F103C6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; _ANYID_GD32_; _ANYID_HSE12P00_; _ANYID_BOOT_
  ICCARM.CCIncludePath2: ..\; ..\inc; E:\AnyID\AnyID_Embedded\V1.1.0\STM32_lib_V3.3\startup; E:\AnyID\AnyID_Embedded\V1.1.0\STM32_lib_V3.3\inc; E:\AnyID\AnyID_Embedded\V1.1.0\AnyID_lib_V1.1.0\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Boot.hex
  ILINK.IlinkOutputFile: Boot.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../AnyID_Embedded/V1.1.0/STM32_lib_V3.3/startup/: system_stm32f10x.c
  group EWARMv5
    ../src/: AnyID_FlashM25.c
    ../../../../../AnyID_Embedded/V1.1.0/STM32_lib_V3.3/startup/: startup_stm32f10x_hd.s
  group Main
    ../: main.c stm32f10x_conf.h stm32f10x_it.c
  group StdPeriph_Driver
    ../../../../../AnyID_Embedded/V1.1.0/STM32_lib_V3.3/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c
  group User
    ../src/: AnyID_Boot_Device.c AnyID_Boot_EC20.c AnyID_Boot_EC20_HL.c AnyID_Boot_Flash_HL.c AnyID_Boot_FlashM25.c AnyID_Boot_FRam.c AnyID_Boot_FRam_HL.c AnyID_Boot_Gate.c AnyID_Boot_Gate_HL.c AnyID_Boot_SysCfg.c AnyID_Boot_SysTick_HL.c AnyID_Boot_Uart.c AnyID_FRam.c AnyID_Uart_Receive.c
    ../../../../../AnyID_Embedded/V1.1.0/AnyID_lib_V1.1.0/src/: AnyID_Stdlib.c
