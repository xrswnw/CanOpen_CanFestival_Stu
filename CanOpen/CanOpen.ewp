# IAR project CanOpen.ewp, settings and files
configuration Build (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C6 ST STM32F103C6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; _ANYID_GD32_
  ICCARM.CCIncludePath2: ..\; ..\inc; E:\AnyID\AnyID_Embedded\V1.1.0\STM32_lib_V3.3\startup; E:\AnyID\AnyID_Embedded\V1.1.0\STM32_lib_V3.3\inc; E:\AnyID\AnyID_Embedded\V1.1.0\AnyID_lib_V1.1.0\inc; ..\CanFestival; ..\CanFestival\driver; ..\CanFestival\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CanOpen.hex
  ILINK.IlinkOutputFile: CanOpen.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CanFestival
    ../CanFestival/src/: dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer.c
  group CMSIS
    ../../../../AnyID_Embedded/V1.1.0/STM32_lib_V3.3/startup/: system_stm32f10x.c
  group EWARMv5
    ../../../../AnyID_Embedded/V1.1.0/STM32_lib_V3.3/startup/: startup_stm32f10x_hd.s
  group Main
    ../: main.c stm32f10x_conf.h stm32f10x_it.c
  group StdPeriph_Driver
    ../../../../AnyID_Embedded/V1.1.0/STM32_lib_V3.3/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group User
    ../src/: AnyID_CanOpen_Can_HL.c AnyID_CanOpen_Device.c AnyID_CanOpen_FRam.c AnyID_CanOpen_FRam_HL.c AnyID_CanOpen_Periph_HL.c AnyID_CanOpen_RS485.c AnyID_CanOpen_RS485_HL.c AnyID_CanOpen_RTC.c AnyID_CanOpen_SysCfg.c AnyID_CanOpen_SysTick_HL.c AnyID_CanOpen_Tim_HL.c AnyID_CanOpen_Uart_Receive.c AnyID_CanOpen_WDG_HL.c AnyID_FRam.c
    ../CanFestival/driver/: AnyId_Canopen_Slave.c
    ../../../../AnyID_Embedded/V1.1.0/AnyID_lib_V1.1.0/src/: AnyID_Stdlib.c
